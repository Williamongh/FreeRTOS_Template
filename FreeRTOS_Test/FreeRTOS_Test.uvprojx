# Keil uVision project FreeRTOS_Test.uvprojx, settings and files
target FreeRTOS_Test (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\FreeRTOS\inc;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./User/: main.c user_tasks.c stm32f10x_it.c Init.c include.h stm32f10x_conf.h FreeRTOSConfig.h
  group Hardware
    ./Hardware/: UART.c UI.c
  group FWLib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
